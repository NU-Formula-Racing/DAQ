# Repository NU-Formula-Racing/DAQ

File README.md:

# DAQ
To see what has changed across revisions:  
1. Look at the commit history  
2. Click on the specific commit in question  
<!-- end of list -->
Visual instructions:

## EAGLE design mmt_xbee.brd

Schematic: mmt_xbee.sch, sheet 1

Parts:
B1: ARDUINO_MEGA_R3FULL; ARDUINO_MEGA
BRAKEPRES: 156120M173000
BRAKETEMP: 156120M173000
C1, C2, C5, C26: 10μF; C1206
C3, C4: 8.2pF; C1206
C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C28, C29, C30, C31, C32, C33, C34, C35: 0.1μF; C1206
C27: 22μF; C1206
COOLANTTEMP: 156120M173000
DAQ: 156120M173000
DASH: 156120M173000
IC1: P82B715D; SOIC127P600X175-8N
INTAKEPRES: 156120M173000
INTAKETEMP: 156120M173000
J1: 6473427-1; TE_6473427-1
J2: VR10S05; CONN3_10S05_XPP
JP1: DNP; 1X04
LAMBDAS: 156120M173000
OILPRES: 156120M173000
OILTEMP: 156120M173000
Q1, Q2: MOSFET-NCHANNELSMD; SOT23-3
R1, R2, R3, R4, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24: 1kΩ; R1206
R5, R6, R7, R8, R9, R10, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R71: 10kΩ; R1206
R59, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R70: 350Ω; R1206
REC: SML-LX1206SIC-TR; LED_SML-LX1206SIC-TR_LUM
SHOCKPOT: 156120M173000
SPARE1, SPARE2: 156120M173000
SW1, SW2: CTS_ELECTROCOMPONENTS_204-211STCTS_ELECTROCOMPONE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; CTS_ELECTROCOMPONENTS_204-211ST_0
U1: XC6220B331MR-G; SOT-25_TOR
U6, U7: ADS1119IPWT; PW0016A_N
XB1: XBEE_MMT

Connections:
2AIC0: C28.2, R51.1, U7.11 (AIN0)
2AIC1: C29.2, R52.1, U6.11 (AIN0)
2AIC2: C30.2, R53.1, U7.10 (AIN1)
2AIC3: C31.2, R54.1, U6.10 (AIN1)
3.3V: C2.1, R2.2, R4.2, R7.2, R8.1, U1.5 (VOUT)
3AIC0: C32.2, R55.1, U7.7 (AIN2)
3AIC1: C33.2, R56.1, U6.7 (AIN2)
3AIC2: C34.2, R57.1, U7.6 (AIN3)
3AIC3: C35.2, R58.1, U6.6 (AIN3)
4: B1.4, BRAKETEMP.4 (K_GREEN)
5: B1.5, DASH.2 (K_BLUE)
5V: B1.5V@0 (5V), C1.2, C22.2, C23.1, C24.2, C25.1, C27.2, IC1.8 (VCC), J1.12, J1.15, J2.3, JP1.1, Q1.1 (G), Q2.1 (G), R1.2, R3.2, R5.1, R9.1, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.1, R41.1, R42.1, R43.2, R44.1, R45.1, R46.2, R47.1, R48.1, R49.1, R50.2, R60.1, R63.1, R66.1, R69.1, SW1.1, SW2.1, U1.1 (VIN), U6.3 (RESET_N), U6.12 (AVDD), U6.13 (DVDD), U7.3 (RESET_N), U7.12 (AVDD), U7.13 (DVDD); also elsewhere on the board
5VOR0V: R61.1, R64.1, R67.1, R70.1, SW1.2
6: B1.6, DASH.3 (K_RED)
7: B1.7, DASH.4 (K_GREEN)
8: B1.8, LAMBDAS.2 (K_BLUE)
9: B1.9, LAMBDAS.3 (K_RED)
10: B1.10, LAMBDAS.4 (K_GREEN)
12V: B1.VIN, C26.2, J1.26, J1.54, J2.1
14: B1.14 (14(TX3)), BRAKETEMP.3 (K_RED)
15: B1.15 (15(RX3)), BRAKETEMP.2 (K_BLUE)
16: B1.16 (16(TX2)), SHOCKPOT.4 (K_GREEN)
17: B1.17 (17(RX2)), SHOCKPOT.3 (K_RED)
18: B1.18 (18(TX1)), SHOCKPOT.2 (K_BLUE)
19: B1.19 (19(RX1)), BRAKEPRES.4 (K_GREEN)
22: B1.22, BRAKEPRES.3 (K_RED)
23: B1.23, BRAKEPRES.2 (K_BLUE)
24: B1.24, INTAKEPRES.4 (K_GREEN)
25: B1.25, INTAKEPRES.3 (K_RED)
26: B1.26, INTAKEPRES.2 (K_BLUE)
27: B1.27, INTAKETEMP.4 (K_GREEN)
28: B1.28, INTAKETEMP.3 (K_RED)
29: B1.29, INTAKETEMP.2 (K_BLUE)
30: B1.30, COOLANTTEMP.4 (K_GREEN)
31: B1.31, COOLANTTEMP.3 (K_RED)
32: B1.32, COOLANTTEMP.2 (K_BLUE)
33: B1.33, OILPRES.4 (K_GREEN)
34: B1.34, OILPRES.3 (K_RED)
35: B1.35, OILPRES.2 (K_BLUE)
36: B1.36, OILTEMP.4 (K_GREEN)
37: B1.37, OILTEMP.3 (K_RED)
38: B1.38, OILTEMP.2 (K_BLUE)
39: B1.39, SPARE1.4 (K_GREEN)
40: B1.40, SPARE1.3 (K_RED)
41: B1.41, SPARE1.2 (K_BLUE)
42: B1.42, SPARE2.4 (K_GREEN)
43: B1.43, SPARE2.3 (K_RED)
44: B1.44, SPARE2.2 (K_BLUE)
45: B1.45, DAQ.4 (K_GREEN)
46: B1.46, DAQ.3 (K_RED)
47: B1.47, DAQ.2 (K_BLUE)
48: B1.48, R71.1, SW2.2
A0: B1.A0 (A0(RX0)), C6.2, R25.2
A0IN: J1.18, R25.1
A1: B1.A1 (A1(TX0)), C7.2, R26.2
A1IN: J1.19, R26.1
A2: B1.A2, C8.2, R27.2
A2IN: J1.20, R27.1
A3: B1.A3, C9.2, R28.2
A3IN: J1.10, R28.1
A4: B1.A4, C10.2, R29.2
A4IN: J1.1, R29.1
A5: B1.A5, C11.2, R30.2
A5IN: J1.11, R30.1
A6: B1.A6, C12.2, R31.2
A6IN: J1.9, R31.1
A7: B1.A7, C13.2, R32.2
A7IN: J1.17, R32.1
A8: B1.A8, C14.2, R33.2
A8IN: J1.8, R33.1
A9: B1.A9, C15.2, R34.2
A9IN: J1.16, R34.1
A10: B1.A10, C16.2, R35.2
A10IN: J1.7, R35.1
A11: B1.A11, C17.2, R36.2
A11IN: J1.6, R36.1
A12: B1.A12, C18.2, R37.2
A12IN: J1.13, R37.1
A13: B1.A13, C19.2, R38.2
A13IN: J1.4, R38.1
A14: B1.A14, C20.2, R39.2
A14IN: J1.5, R39.1
A15: B1.A15, C21.2, R40.2
A15IN: J1.14, R40.1
CALIB: B1.13, J1.31, R50.1
CANHI: J1.60, JP1.3
CANLO: J1.53, JP1.4
CAN_CS: B1.49; also elsewhere on the board
DIN: Q1.2 (S), R3.1, XB1.4 (DIN/C\O\N\F\I\G\/DIO14)
DOUT: Q2.2 (S), R1.1, XB1.3 (DOUT/DIO13)
FL_WS: B1.2, J1.25, R47.2
FR_WS: B1.3, J1.34, R48.2
GND: B1.GND@0 (GND), C1.1, C2.2, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.2, C24.1, C25.2, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, IC1.4 (GND), J1.21, J1.22, J1.23, J1.24, J1.50, J1.51, J1.52, J2.2, JP1.2, R6.1, R59.2, R62.2, R65.2, R68.2, R71.2, U1.2 (VSS), U6.4 (DGND), U6.5 (AGND), U7.4 (DGND), U7.5 (AGND), XB1.1 (GND), XB1.10 (GND), XB1.12 (GND), XB1.21 (GND), XB1.32 (GND), XB1.34 (GND); also elsewhere on the board
LCL: IC1.7 (LY), J1.35, J1.36, J1.37, J1.38, J1.39, J1.40, J1.41, J1.42, J1.43, J1.44, J1.45, J1.46, J1.47, J1.48, J1.49, J1.57, R10.1
LDA: IC1.2 (LX), J1.32, R9.2
MISO: B1.50; also elsewhere on the board
MOSI: B1.51; also elsewhere on the board
unnamed: INTAKEPRES.1 (COMMON_ANODE), R16.1
unnamed: R5.2, R6.2, U1.3 (CE)
unnamed: DASH.1 (COMMON_ANODE), R11.1
unnamed: INTAKETEMP.1 (COMMON_ANODE), R17.1
unnamed: COOLANTTEMP.1 (COMMON_ANODE), R18.1
unnamed: OILPRES.1 (COMMON_ANODE), R19.1
unnamed: OILTEMP.1 (COMMON_ANODE), R20.1
unnamed: R21.1, SPARE1.1 (COMMON_ANODE)
unnamed: R22.1, SPARE2.1 (COMMON_ANODE)
unnamed: DAQ.1 (COMMON_ANODE), R23.1
unnamed: R24.2, REC.2
unnamed: R43.1, U6.14 (DRDY_N)
unnamed: LAMBDAS.1 (COMMON_ANODE), R12.1
unnamed: BRAKETEMP.1 (COMMON_ANODE), R13.1
unnamed: R14.1, SHOCKPOT.1 (COMMON_ANODE)
unnamed: BRAKEPRES.1 (COMMON_ANODE), R15.1
unnamed: R51.2, R59.1, R60.2
unnamed: C3.2, C4.2, C5.2, XB1.2 (VCC)
unnamed: R8.2, XB1.9 (D\T\R\/DIO8)
unnamed: R53.2, R62.1, R63.2
unnamed: R7.1, XB1.27 (R\T\S\/DIO6)
unnamed: R46.1, U7.14 (DRDY_N)
unnamed: R55.2, R65.1, R66.2
unnamed: R41.2, U6.9 (REFP)
unnamed: R42.2, U6.8 (REFN)
unnamed: R44.2, U7.9 (REFP)
unnamed: R45.2, U7.8 (REFN)
unnamed: R57.2, R68.1, R69.2
REC: B1.11, J1.33, R49.2, REC.1
RX0: B1.0 (0(RX0)), Q2.3 (D), R2.1
SCK: B1.52; also elsewhere on the board
SCL: B1.21 (21(SCL)), IC1.6 (SY), U6.2 (A1), U6.16 (SCL), U7.1 (A0), U7.16 (SCL)
SDA: B1.20 (20(SDA)), IC1.3 (SX), U6.1 (A0), U6.15 (SDA), U7.2 (A1), U7.15 (SDA)
SD_CS: B1.53; also elsewhere on the board
SG_11: J1.30, R58.2, R70.2
SG_21: J1.29, R56.2, R67.2
SG_31: J1.28, R54.2, R64.2
SG_41: J1.27, R52.2, R61.2
TX0: B1.1 (1(TX0)), Q1.3 (D), R4.1

Notes on the sheet:
Analog inputs
Indicator LEDs
ADCs
Arduino Mega
Wheatstone bridges
Connectors
Peripherals
CAN/SD shield
XBee
I2C Buffer
Buck converter

Parts:
U4: ARDUINO_R3_SHIELD; UNO_R3_SHIELD

Connections:
5V: U4.5V; also elsewhere on the board
AREF: U4.AREF
CAN_CS: U4.D10 (*D10); also elsewhere on the board
CAN_INT: U4.D2
D3: U4.D3 (*D3)
D4: U4.D4
D5: U4.D5 (*D5)
GND: U4.GND@0 (GND), U4.GND@1 (GND), U4.GND@2 (GND); also elsewhere on the board
JOY-CLICK: U4.A4
JOY-DOWN: U4.A3
JOY-LEFT: U4.A2
JOY-RIGHT: U4.A5
JOY-UP: U4.A1
LCD: U4.D6 (*D6)
LED1: U4.D8
LED2: U4.D7
MISO: U4.D12; also elsewhere on the board
MOSI: U4.D11 (*D11); also elsewhere on the board
RS: U4.RES
RX: U4.RX
SCK: U4.D13; also elsewhere on the board
SD_CS: U4.D9 (*D9); also elsewhere on the board
TX: U4.TX

Notes on the sheet:
Arduino Connections
LCD
Joystick
5V compatible LCDs
GPS
Change jumpers to select GPS communication on Software Serial or UART
Disconnect jumper for GPS without GND on pin 5.
microSD
Revision by: Toni Klopfenstein
v13

Board: 2 copper layers, 204.4 x 88.6 mm, 134 parts (107 on the bottom side), 136 nets.

## Commit log (part)

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2022-03-25 Getting ready for 2nd rev
    Replaced XBee's voltage regulator with a new one that's better spec'ed
    Swapped out the old XBee library for a new one (SMT XBee 3 Pro)
    Fixed general design of XBee (5V -> 3.3V & added decoupling caps)
    Standardized capacitor and resistor library
    To do:
    Place components on board (passive components on bottom)
2022-03-25 added assets for README
2022-03-26 Revised LEDs
    Changed LED pins on Arduino Mega (will need to adjust program accordingly)
    Reorganized LED pins
    Placed LEDs and corresponding resistors on board
2022-03-27 Through-hole XBee
    This rev uses the through-hole XBee in case we can't get our hands on the SMT XBee
    Finished arranging components on board
    Updated the 1206cap library on the board
2022-03-27 SMT XBee
    This rev uses the SMT XBee
    Finished arranging components on board
    Fixed pins on XBee (mixed up RESET and RTS pins)
    Updated the 1206cap library on the board
2022-03-27 SMT XBee
    Added XBee 3D model
    Moved connector to be flush with board
2022-03-27 Moved the connector to be flush & pushed to Fusion 360
2022-03-29 Made board for MMT XBee
    Still need to add 3D package for the MMT XBee but have already pushed to Fusion for now
2022-03-29 Added MMT XBee 3D package & pushed to Fusion 360
2022-03-30 Fixed keepout on XBee and modified testing vias
    Removed all the copper (top & bottom) at the top of the XBee
    Made testing vias bigger
    Added a 3.3V testing via

Notices in the files:
parts and their libraries:
SparkFun-Boards: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
SparkFun-Connectors: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
